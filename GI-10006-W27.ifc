Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-01-09T12:21:00
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: GI-10006-W27
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Gino Bollards LED
In: Default Building
Type - Description: Wall mounted luminaires with upward and downward light distributions. Ideally suited to illuminate wall and surfaces, all possible to create light accents on vertical surfaces using LED lamp. The luminaire rated as CLASS I with integral driver. Colour temperature 2700K, 3000K and 4000K, LED CRI >80 and life time 50,000 Hours. Low copper content corrosion resistant die-cast aluminum frame and body. Stainless steel screws. Durable silicone rubber gasket and impact resistant toughened glass diffuser The luminaire is treated with a chemical chromatized protection before powder coating, ensuring high corrosion resistance. Lamp: 2 LED LED colour: 2700 K Power: 8 w. Weight: 8.3 kg. IP65 /EN 60598/CLASS I / CE /IK04; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Gino, Bollard-Garden light-Pilar light; Housing color: All
General Information - Weight: 8.3 kg; Case length: 21 cm; Case width: 20.2 cm; Case height: 100 cm; Article name: Gino Bollards LED; Uld creation date: 01.09.2019 00:00:00
Photometric Information - Light output ratio: 1.00011; Luminous flux: 486.946 lm; Lamp names: GI-10006-W27
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 8.2 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 8.2 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 486.946 lm; LightEmitterNominalPower: 8.2 W; Spectrum: 380: 0.000202083, 385: 0.00029239, 390: 0.000326243, 395: 0.000598706, 400: 0.00122083, 405: 0.00208526, 410: 0.00406383, 415: 0.00702515, 420: 0.0119542, 425: 0.0189158, 430: 0.033059, 435: 0.0574187, 440: 0.101078, 445: 0.154923, 455: 0.160697, 465: 0.102441, 470: 0.079361, 475: 0.0654482, 480: 0.0602982, 485: 0.059364, 490: 0.0616837, 500: 0.0724298, 505: 0.0795063, 510: 0.0861566, 515: 0.0947302, 520: 0.103368, 525: 0.111355, 530: 0.12235, 535: 0.131938, 540: 0.143665, 545: 0.156052, 550: 0.168528, 555: 0.182042, 560: 0.196912, 565: 0.211639, 570: 0.228505, 575: 0.244371, 580: 0.256141, 585: 0.269453, 590: 0.277391, 595: 0.286457, 600: 0.291327, 605: 0.294565, 610: 0.293546, 615: 0.290882, 620: 0.28504, 625: 0.278217, 630: 0.266043, 635: 0.25492, 640: 0.242662, 645: 0.228557, 650: 0.215023, 655: 0.199732, 660: 0.185641, 665: 0.168742, 670: 0.15569, 675: 0.143014, 680: 0.128793, 685: 0.117991, 690: 0.105071, 695: 0.0958027, 700: 0.0853801, 705: 0.0770554, 710: 0.068426, 715: 0.0603295, 720: 0.0540097, 725: 0.0483628, 730: 0.0423836, 735: 0.0378708, 740: 0.0338178, 745: 0.0300972, 750: 0.0264363, 755: 0.0230856, 760: 0.0205322, 765: 0.0183139, 770: 0.0161183, 775: 0.0141769, 780: 0.0123993; ColorTemperature: 2665 K; ColorAppearance: 3114 K
